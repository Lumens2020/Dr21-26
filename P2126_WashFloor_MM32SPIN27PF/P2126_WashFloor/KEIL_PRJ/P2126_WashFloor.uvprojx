# Keil uVision project P2126_WashFloor.uvprojx, settings and files
target MM32 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MM32SPIN27PF MindMotion
  pack: MindMotion.MM32SPIN2x_DFP.1.1.6
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: P2126_WashFloor +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\Device\CMSIS\KEIL_CORE;..\..\Device\MM32SPIN2xx_p_LIB\HAL_lib\inc;..\..\Device\MM32SPIN2xx_p_LIB\Include;..\USER;..\HARDWARE\MCUConfigure\ADC;..\HARDWARE\MCUConfigure\EEPROM;..\HARDWARE\MCUConfigure\GPIO;..\HARDWARE\MCUConfigure\INIT;..\HARDWARE\MCUConfigure\IWDG;..\HARDWARE\MCUConfigure\TIM;..\HARDWARE\MCUConfigure\UART;..\HARDWARE\WashFloorFunction\BLDC;..\HARDWARE\WashFloorFunction\BRUSH;..\HARDWARE\WashFloorFunction\CHG;..\HARDWARE\WashFloorFunction\CLEANWATER;..\HARDWARE\WashFloorFunction\COMMBLDC;..\HARDWARE\WashFloorFunction\COMMBMS;..\HARDWARE\WashFloorFunction\COMMSCREEN;..\HARDWARE\WashFloorFunction\CONTROL;..\HARDWARE\WashFloorFunction\DRY;..\HARDWARE\WashFloorFunction\KEY;..\HARDWARE\WashFloorFunction\PUMP;..\HARDWARE\WashFloorFunction\SEWAGE;..\HARDWARE\WashFloorFunction\TILT;..\HARDWARE\WashFloorFunction\VOICE;..\HARDWARE\WashFloorFunction\WATERELEC;..\HARDWARE\WashFloorFunction\COMMTEST;..\HARDWARE\MCUConfigure\COMP;..\HARDWARE\WashFloorFunction\COMMFCT;..\HARDWARE\WashFloorFunction\IMPROVE
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group USER
    ../USER/: main.c
  group STARTUP
    ../../Device/MM32SPIN2xx_p_LIB/Source/: system_MM32SPIN2xx_p.c
    ../../Device/MM32SPIN2xx_p_LIB/Source/KEIL_StartAsm/: startup_MM32SPIN2xx_p.s
  group HALIib
    ../../Device/MM32SPIN2xx_p_LIB/HAL_lib/src/: HAL_adc.c HAL_comp.c HAL_crc.c HAL_div.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_op.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group HARDWARE
    ../HARDWARE/MCUConfigure/ADC/: adc.c
    ../HARDWARE/MCUConfigure/EEPROM/: eeprom.c
    ../HARDWARE/MCUConfigure/GPIO/: gpio.c
    ../HARDWARE/MCUConfigure/INIT/: init.c
    ../HARDWARE/MCUConfigure/IWDG/: iwdg.c
    ../HARDWARE/MCUConfigure/TIM/: timer.c
    ../HARDWARE/MCUConfigure/UART/: uart.c
    ../HARDWARE/WashFloorFunction/BLDC/: bldc.c
    ../HARDWARE/WashFloorFunction/BRUSH/: brush.c
    ../HARDWARE/WashFloorFunction/CHG/: charge.c
    ../HARDWARE/WashFloorFunction/CLEANWATER/: cleanwater.c
    ../HARDWARE/WashFloorFunction/COMMBLDC/: commbldc.c
    ../HARDWARE/WashFloorFunction/COMMBMS/: commbms.c
    ../HARDWARE/WashFloorFunction/COMMSCREEN/: commscreen.c
    ../HARDWARE/WashFloorFunction/DRY/: dry.c
    ../HARDWARE/WashFloorFunction/KEY/: key.c keyAD.c keyIO.c
    ../HARDWARE/WashFloorFunction/PUMP/: waterpump.c
    ../HARDWARE/WashFloorFunction/SEWAGE/: sewage.c
    ../HARDWARE/WashFloorFunction/TILT/: tilt.c
    ../HARDWARE/WashFloorFunction/VOICE/: voice.c voicelist.c
    ../HARDWARE/WashFloorFunction/WATERELEC/: waterelec.c
    ../HARDWARE/WashFloorFunction/CONTROL/: error.c control.c
    ../HARDWARE/WashFloorFunction/COMMTEST/: commtest.c
    ../HARDWARE/MCUConfigure/COMP/: compare.c
    ../HARDWARE/WashFloorFunction/COMMFCT/: commfct.c
    ../HARDWARE/WashFloorFunction/IMPROVE/: improve.c
